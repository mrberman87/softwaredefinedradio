<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>untitled</value></param>
<param><key>author</key><value>unknown</value></param>
<param><key>description</key><value>gnuradio flow graph</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>access_code</key><value></value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>1000</value></param>
</block>
<block>
<key>random_source_x</key>
<param><key>id</key><value>random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>(16*samp_rate)</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_dxpsk_mod</key>
<param><key>id</key><value>blks2_dxpsk_mod_0</value></param>
<param><key>type</key><value>dbpsk</value></param>
<param><key>samples_per_symbol</key><value>8</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>gray_code</key><value>True</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>(16*samp_rate)</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>/home/sab/Desktop/data.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>random_source_x_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>blks2_dxpsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_dxpsk_mod_0</source_block_id><sink_block_id>gr_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_1</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_1</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
