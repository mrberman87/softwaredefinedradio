<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Tx_Kill</value></param>
<param><key>title</key><value>Tx_Kill</value></param>
<param><key>author</key><value>Charles Judah</value></param>
<param><key>description</key><value>gnuradio flow graph</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>256e3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>usrp_simple_sink_x</key>
<param><key>id</key><value>usrp_simple_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>interpolation</key><value>500</value></param>
<param><key>frequency</key><value>(440009220)</value></param>
<param><key>gain</key><value>0</value></param>
<param><key>side</key><value>A</value></param>
<param><key>transmit</key><value>tx_enb</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>usrp_simple_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>const_source_x_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
